# Keil uVision project RollingBall.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RollingBall +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\IIC;..\HARDWARE\EXTI;..\Ball\CONTROL;..\Ball\DMP;..\Ball\HanWork;..\Ball\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s
  group User
    ./: main.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Hardware
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/EXTI/: exti.c
  group Ball
    ../Ball/CONTROL/: control.c
    ../Ball/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Ball/MPU6050/: MPU6050.c
    ../Ball/HanWork/: RollingBall.c
